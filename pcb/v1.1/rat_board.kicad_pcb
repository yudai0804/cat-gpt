# Repository yudai0804/cat-gpt

File readme.md:

# cat-gpt

# doc

[uml](./doc/uml.md)  
[tcp-protocol](./doc/tcp-protocol.md)  
[mcu](./doc/mcu.md)

## KiCad design pcb/v1.1/rat_board.kicad_pcb

Parts:
BZ1: Buzzer; PKM22EPP-40
C1: 2.2u; C_Disc_D7.0mm_W2.5mm_P5.00mm
C2: 0.33u; C_Disc_D7.0mm_W2.5mm_P5.00mm
D1: LED BLUE; LED_D5.0mm
D2: LED WHITE; LED_D5.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1, J3, J5, J7: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J6: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R1, R2: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3, R4: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_SPDT; switch
SW2: SW_Push; tact_switch
U1: ESP32
U2: DRV8835
U3: NJM2845DL-05; NJM2845

Connections:
+3.3V: J2.1, R1.1, R2.1, U1.1 (3V3), U2.7 (Vcc)
+5V: C1.1, J6.1, U1.19 (5V), U3.3 (OUT)
AIN1: U1.33 (IO21), U2.9 (AIN1)
AIN2: U1.31 (IO19), U2.10 (AIN2)
BIN1: U1.30 (IO18), U2.11 (BIN1)
BIN2: U1.29 (IO5), U2.12 (BIN2)
BUZZER: BZ1.1 (-), U1.37 (IO23)
GND: BZ1.2 (+), C1.2, C2.1, D1.1 (K), D2.1 (K), J1.2, J2.2, J6.3, J7.2, SW2.1, U1.14 (GND), U1.32 (GND), U1.38 (GND), U2.6 (GND), U3.2 (GND)
LED_A: R3.2, U1.12 (IO14)
LED_B: R4.2, U1.13 (IO12)
LIMIT_SW: J1.1, R1.2, U1.23 (IO15)
MODE: U1.36 (IO22), U2.8 (MODE)
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R4.1
unnamed: J3.1, U2.4 (BOUT1)
unnamed: J3.2, U2.5 (BOUT2)
unnamed: J5.1, U2.2 (AOUT1)
unnamed: J5.2, U2.3 (AOUT2)
unnamed: J7.1, SW1.2 (B)
RGBLED: J6.2, U1.26 (IO4)
SCL: J2.4, U1.28 (IO17)
SDA: J2.3, U1.27 (IO16)
SW: R2.2, SW2.2, U1.11 (IO27)
VCC: C2.2, SW1.1 (A), U2.1 (VM), U3.1 (IN)

Notes on the sheet:
モータードライバ
ESP32
コネクタ
ToF
ロジック電源
rgbled
デバッグ用スイッチ
モーターB
モーター電源
input only
IO15はbootと共有
デバッグ用LED
GPIO6~11まで使用不可 GPIO0,2,5,12,15 を使うのは非推奨
モーターA

Board: 2 copper layers, 70.0 x 70.0 mm, 24 parts (0 on the bottom side), 24 nets.

## KiCad design pcb/v1.0/rat_board.kicad_pcb

Board: 2 copper layers, 53.3 x 72.6 mm, 9 parts (0 on the bottom side), 21 nets.

Parts:
J1, J3, J4, J5: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J6: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: ESP32
U2: DRV8835

Connections:
3.3V-1: J2.3, U1.15 (IO13)
3.3V-2: U1.29 (IO5), U2.7 (Vcc)
+6V: U1.19 (5V), U2.1 (VM)
AIN1: U1.36 (IO22), U2.9 (AIN1)
AIN2: U1.33 (IO21), U2.10 (AIN2)
BIN1: U1.31 (IO19), U2.11 (BIN1)
BIN2: U1.30 (IO18), U2.12 (BIN2)
GND: J1.2, J2.4, J4.2, U1.14 (GND), U1.32 (GND), U1.38 (GND), U2.6 (GND)
MODE: U1.37 (IO23), U2.8 (MODE)
unnamed: J1.1, R1.2, U1.10 (IO26)
unnamed: J3.1, U2.4 (BOUT1)
unnamed: J3.2, U2.5 (BOUT2)
unnamed: J4.1, U1.28 (IO17)
unnamed: J5.1, U2.2 (AOUT1)
unnamed: J5.2, U2.3 (AOUT2)
unnamed: J6.1, U1.26 (IO4)
unnamed: J6.2, U1.25 (IO0)
unnamed: J6.3, U1.24 (IO2)
unnamed: R1.1, U1.1 (3V3)
SCL: J2.1, U1.6 (IO35)
SDA: J2.2, U1.7 (IO32)

## Code that names these connections

File mcu/rat_board/src/rat/rat.h:

/**
 * @file rat.h
 * @brief
 */

#pragma once

#include <sys/_stdint.h>

#include "control/trapezoid.h"
#include "control/two_wheel.h"
#include "driver/VL53L0X.h"
#include "driver/buzzer.h"
#include "driver/drv8835.h"
#include "driver/led.h"
#include "driver/switch.h"
#include "driver/tof.h"
#include "timer/timer_1ms.h"
#include "timer/timer_base.h"

namespace rat {

template <typename T>
class Rat {
public:
  static constexpr float NORMAL_VELOCITY = 0.5f;
  static constexpr float NORMAL_OMEGA = 0.5f;
  // マイコンのペリフェラル関係
  VL53L0X vl53l0x_;
  driver::Buzzer buzzer_{23, 0};
  driver::DRV8835::HardwareConfig drv8835_hardware_config_ = {
      .mode_pin = 22,
      .ain1_pin = 21,
      .ain2_pin = 19,
      .bin1_pin = 18,
      .bin2_pin = 5,
      .ain1_channel = 1,
      .ain2_channel = 2,
      .bin1_channel = 3,
      .bin2_channel = 4,
      .pwm_frequency = 1000,
      .pwm_resolution_bit = 10,
      .pwm_resolution = 1024};
  driver::DRV8835 drv8835_{drv8835_hardware_config_};
  driver::LED<timer::Timer1ms> led_red_{12};
  driver::LED<timer::Timer1ms> led_white_{14};
  driver::Switch<timer::Timer1ms> limit_switch_{15, 1};
  driver::Switch<timer::Timer1ms> ui_switch_{27, 1};
  driver::ToF tof_{&vl53l0x_};
  // 制御関連
  control::Trapezoid trapezoid_velocity_{1.0f, 0.01f};
  control::Trapezoid trapezoid_omega_{1.0f, 0.01f};
  control::TwoWheel two_wheel_{1.0f};

public:
  Rat() {}
  void init() {
    Serial.begin(115200);
    Wire.begin(16, 17, 100000);
    buzzer_.init();
    drv8835_.init();
    led_red_.init();
    led_white_.init();
    limit_switch_.init();
    ui_switch_.init();
    tof_.init();
    printf("rat hardware initialize finish\r\n");
  }

  void onInterrupt1ms() {
    led_red_.onInterrupt();
    led_white_.onInterrupt();
    limit_switch_.onInterrupt();
    ui_switch_.onInterrupt();
  }

  void onInterruptForToF() {
    tof_.onInterrupt();
  }

  void resetTrapezoid() {
    trapezoid_velocity_.reset();
    trapezoid_omega_.reset();
  }

  void runByVelocity(const float velocity, const float omega) {
    float v = trapezoid_velocity_.calculate(velocity);
    float _omega = trapezoid_omega_.calculate(omega);
    two_wheel_.calculateByVelocity(v, _omega);
    drv8835_.output(two_wheel_.getVl(), two_wheel_.getVr());
  }

  void runByOmega(const float omega, const float turning_radius) {
    float _omega = trapezoid_omega_.calculate(omega);
    two_wheel_.calculateByOmega(_omega, turning_radius);
    drv8835_.output(_omega, turning_radius);
  }

  void stop() {
    resetTrapezoid();
    drv8835_.output(0.0f, 0.0f);
  }

  void beep(driver::Buzzer::MusicScale scale, uint32_t time) {
    buzzer_.beep(scale, time);
  }

  void straight(float velocity = NORMAL_VELOCITY) {
    runByVelocity(velocity, 0.0f);
  }

  void rotate(float omega = NORMAL_OMEGA) {
    runByVelocity(omega, 0);
  }

  uint16_t getDistance() { return tof_.getDistance(); }
  driver::SwitchStatus getLimitSwitch() { return limit_switch_.getStatus(); }
};
}  // namespace rat

## Commit log

2023-12-25 init
2023-12-25 feat: drv8835のコードをとりあえず書いた
2023-12-27 feat: drv8835に回転方向を選択する機能を追加
2023-12-30 change directory
2023-12-30 fix symbolik link
2024-01-01 doc: update readme
2024-01-01 change directory name. inc->include
2024-01-01 fix: 変数の初期値を設定
2024-01-02 feat: timer classを実装
2024-01-02 style: update comment
2024-01-02 新しいLEDの実装ちゃんと動いた
2024-01-02 feat: blinkをfrequencyとintervalの両方に対応
2024-01-02 feat: switchも新しいtimerに対応
2024-01-02 doc: readmeにピンアサイン書いた
2024-01-02 buzzer動いた
2024-01-02 モタドラのフットプリント間違ってて泣いちゃった。フットプリント間違ってたので動作確認も取れなかった :poop:
2024-01-02 style
2024-01-02 feat: state_machineクラスを実装した
2024-01-02 feat: create state_name.h
2024-01-03 add clang-format
2024-01-03 fix: state_machine.hからnext_stateを削除
2024-01-03 doc: stateの粒度に関する内容を記述
2024-01-03 doc: umlでstate_machine図を描いた
2024-01-03 doc: umlの画像を出力した
2024-01-03 StateMachineクラスの実装が完了
2024-01-04 fix: State構造体で保持する関数をstd::functionから関数ポインタに変更
2024-01-04 fix: 相互にincludeしあっていたのを解消
2024-01-04 feat: trapezoidクラスを追加
2024-01-04 feat: TwoWheelクラスを実装
2024-01-04 feat: Ratクラスにハードウェアに関する処理を書いた
2024-01-04 fix: rat.hのディレクトリを変更
2024-01-04 feat: StateMachineの実装が美しくなった！！！ :tada:
2024-01-05 doc: fix uml
2024-01-05 doc: エラーについて考えるの大変だからやめた :fire:
2024-01-05 doc: IdleステートにWaitForConnectionを追加
2024-01-05 fix: umlでの変更内容をソースコードに反映
2024-01-05 feat: Informationクラスを追加
2024-01-05 fix: ファイル分割
2024-01-05 fix: コンパイルが通らなかったので修正
2024-01-06 add: add wrapper directory
2024-01-06 feat: WifiTCPClientクラスを追加
2024-01-06 style: WifiTCPClientにコメントを追加
2024-01-06 fix: ステートを保持する配列をvectorにした
2024-01-06 mv: create doc directory & move uml directory
2024-01-06 doc: update uml document
2024-01-06 doc: manual stateを追加
2024-01-06 doc: update
2024-01-07 doc: add sequence図
2024-01-07 doc: muc-protocolについてまとめた
2024-01-07 doc: いろんなところに情報が散らばっていたので整理
2024-01-07 doc: tcp-protocolに欠陥があったので、大幅に変更した
2024-01-07 fix: 送信時にstopを有効にするか選択できるようにした
2024-01-07 fix: timerクラスを動的確保することにした
2024-01-07 fix: timerクラスの修正をLEDクラスに反映。正常に動作したので、これから他のクラスにも反映する。
2024-01-07 fix: timerクラスの修正の反映完了
2024-01-08 fix: StateMachineクラスにcallbackを追加
2024-01-08 style: clang-formatの設定を変更
2024-01-08 fix: StateMachineクラスにCallback用setterを追加
2024-01-08 feat:固定長queueを実装
2024-01-08 fix: getterを追加
2024-01-08 feat: Bufferクラスとかいう謎クラス作った
2024-01-08 WifiTCPClientクラスの動作確認を行った
2024-01-08 doc: private_information.hの説明を追加
2024-01-08 fix: ChangeStateを追加
2024-01-10 feat: RatCommunicationを追加
2024-01-10 fix: 公開する必要がないものをpublicからprivateに変更
2024-01-10 feat: timer20msを追加
2024-01-15 fix: いろいろ修正、モーター回った
2024-01-15 fix: モーターがdisableになってた
2024-01-22 change: 通信関係のコードを共通ライブラリに追加
2024-01-22 update: いろいろ変更
2024-01-23 add state
2024-01-23 fix: state_machine周りを改良
2024-01-23 fix: enable_printf(is_printf)が引数の伝搬を起こしていたので削除
2024-01-23 style: コメントを追加
2024-01-23 add: tcp_server.js
2024-01-30 wip: tcp_server.jsを実装中
2024-01-31 tcp_serverをちょっとだけ実装
2024-02-05 StateInformationの送受信に成功
2024-02-05 ESP32-nodejs間で通信できた
2024-02-05 bug fix
2024-02-05 changeStateちゃんと動いてそう
2024-02-05 状態遷移用タスクを追加
2024-02-05 動いてそうで動いてない
2024-02-06 requestChangeStateちゃんと動くようになった
2024-02-06 NoConnectのときにrestoreできるようにした
2024-02-06 ackの処理実装した。動くかはしらない
2024-02-13 よくわかんないけど、Ackちゃんと動いたっぽい
2024-02-13 manual moveに対応
2024-02-13 ピンアサイン間違ってて悲しい
2024-02-22 add: keypress
2024-02-23 feat: ログ周りを見やすくした
2024-02-23 よさそうだ
2024-02-24 feat: feederを追加、あとちょっとだけリファクタ
2024-02-24 なんか動かなかったので、動くようにした。原因は不明
2024-02-24 ファイル名を変えると動かなくなる。
    リンクの順番が影響しているのかの思っている。
    オブジェクトファイルを生成する順番はファイル名関係ないはずだし。
2024-02-25 feat: index.html書いた。これから通信周りの実装
2024-02-25 http postできてるっぽい
2024-02-25 timeout追加
2024-02-25 とりあえず動いた！
2024-02-25 feat: スマホ対応
2024-02-25 森先輩が作った基板データをリポジトリに追加
